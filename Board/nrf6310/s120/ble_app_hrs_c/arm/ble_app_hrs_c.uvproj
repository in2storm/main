# Keil uVision project ble_app_hrs_c.uvproj, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_c +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s120;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_hrs_c.c ble_bas_c.c
    ../: ble_nus.c
  group Libraries
    ../../../../../Source/ble/: ble_debug_assert_handler.c ble_db_discovery.c
    ../../../../../Source/app_common/: app_trace.c pstorage.c app_button.c app_gpiote.c app_timer.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../../Source/twi_master/: twi_hw_master.c
    ../../../../../Source/ble/device_manager/: device_manager_central.c
    ../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_hrs_c +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s120;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\..\..\..\Include\sdk;..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\Source\ble
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
